# Keil uVision project RM2020_infantry.uvprojx, settings and files
target RM2020_infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2020_infantry
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F427xx ARM_MATH_CM4 STM32F427xx,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\zzsadd\algorithm;..\zzsadd\bsp;..\zzsadd\DSP;..\zzsadd\Imu;..\zzsadd\modules;..\zzsadd\Personal;..\zzsadd\usr_task;..\zzsadd\DSP\Include;..\zzsadd\debug
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c iwdg.c rtc.c sdio.c spi.c sys.c stm32f4xx_hal_timebase_tim.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group startup
    ./: startup_stm32f427xx.s
  group bsp/drivers
    ../zzsadd/bsp/: drv_io.c drv_timer.c drv_uart.c drv_can.c drv_adc.c drv_flash.c drv_dbus.c drv_buzzer.c drv_oled.c drv_nuc_interface.c drv_keyboard.c drv_judgesystem.c drv_adc.h drv_buzzer.h drv_can.h drv_dbus.h drv_flash.h drv_io.h drv_judgesystem.h drv_keyboard.h drv_nuc_interface.h drv_timer.h drv_uart.h oled.h oledfont.h
  group algorithm
    ../zzsadd/algorithm/: CRC.c pid.c ramp.c kalman_filter.c usr_math.c CRC.h kalman_filter.h pid.h ramp.h usr_math.h
  group onboard_imu
    ../zzsadd/Imu/: Dataexchange.c drv_imu.c mahony_ahrs.c AHRS.lib AHRS_middleware.c ahrs.h AHRS_middleware.h drv_imu.h IST8310_reg.h mpu6500_reg.h
    ../zzsadd/DSP/: arm_cortexM4lf_math.lib
  group modules
    ../zzsadd/modules/: infantry.c chassis.c gimbal.c shoot.c vision.c global.h chassis.h gimbal.h infantry.h shoot.h vision.h
  group individual_lib
    ../zzsadd/Personal/: ANO_DT.c delay.c STMGood.c ANO_DT.h delay.h STMGood.h
  group tasks
    ../zzsadd/usr_task/: gimbal_task.c chassis_task.c Shoot_task.c imu_update_task.c monitor_task.c debug_printf_task.c chassis_task.h debug_printf_task.h gimbal_task.h imu_update_task.h monitor_task.h Shoot_task.h
  group debug
    ../zzsadd/debug/: config.h key.h periphetal.h parameter.h
software components: CMSIS:CORE 5.2.0
